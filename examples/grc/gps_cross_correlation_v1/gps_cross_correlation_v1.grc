options:
  parameters:
    generate_options: qt_gui
    id: gps_cross_correlation_v1
    output_language: python
    title: gps_cross_correlation_v1
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    rangeType: int
    start: '0'
    step: '1'
    stop: vector_length
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: vector_length * 1000
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: '1023'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vector_length
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: gnss_ca_code_generator_0
  id: gnss_ca_code_generator
  parameters:
    domain: gnss.CA_CODE_DOMAIN_TIME
    sampling_freq: samp_rate
    svid: '20'
    type: fc32
    vlen: '1'
  states: {}
- name: gnss_ca_code_generator_0_0
  id: gnss_ca_code_generator
  parameters:
    domain: gnss.CA_CODE_DOMAIN_TIME
    sampling_freq: samp_rate
    svid: '20'
    type: fc32
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: vector_length
    srate: samp_rate
    type: float
    ymax: '20'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: vector_length
    srate: samp_rate
    type: complex
    ymax: '20'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: vector_length
    srate: samp_rate
    type: complex
    ymax: '20'
    ymin: '0'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_delay_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_throttle_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [gnss_ca_code_generator_0, '0', blocks_throttle_0_0_0, '0']
- [gnss_ca_code_generator_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.5.0-1-g480f600c
