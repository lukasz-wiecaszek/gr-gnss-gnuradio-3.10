options:
  parameters:
    generate_options: qt_gui
    id: gps_pvt_satellite_bcn
    output_language: python
    title: gps_pvt_satellite_bcn
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: svid
  id: variable
  parameters:
    value: '20'
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: samp_rate//1000
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/memyselfandi/projects/sdr-files/gnss/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN.dat
    repeat: 'False'
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gnss_acquisition_and_tracking_0
  id: gnss_acquisition_and_tracking
  parameters:
    debug_ports: 'True'
    dll_bw_coarse: '4.0'
    dll_bw_fine: '2.0'
    identifier: svid
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: '40.0'
    pll_bw_fine: '35.0'
    sampling_freq: samp_rate
  states: {}
- name: gnss_ca_symbols_to_nav_bits_0
  id: gnss_ca_symbols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_doppler_shift_0
  id: gnss_doppler_shift
  parameters:
    receiver_port: 'False'
    x: '3860250'
    y: '1405016'
    z: '4862942'
  states: {}
- name: gnss_nav_message_decoder_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: svid
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_number_file_sink_0
  id: gnss_number_file_sink
  parameters:
    delimiter: '"\n"'
    filename: '"satellite_positions.dat"'
    num_inputs: '1'
    type: f64
    vlen: '3'
  states: {}
- name: gnss_number_file_sink_0_0
  id: gnss_number_file_sink
  parameters:
    delimiter: '"\n"'
    filename: '"satellite_velocities.dat"'
    num_inputs: '1'
    type: f64
    vlen: '3'
  states: {}
- name: gnss_number_file_sink_0_0_0
  id: gnss_number_file_sink
  parameters:
    delimiter: '"\n"'
    filename: '"doppler_shift_measured.dat"'
    num_inputs: '1'
    type: f32
    vlen: '1'
  states: {}
- name: gnss_number_file_sink_0_0_1
  id: gnss_number_file_sink
  parameters:
    delimiter: '"\n"'
    filename: /dev/null
    num_inputs: '1'
    type: f64
    vlen: '1'
  states: {}
- name: gnss_number_file_sink_0_0_2
  id: gnss_number_file_sink
  parameters:
    delimiter: '"\n"'
    filename: '"doppler_shift_evaluated.dat"'
    num_inputs: '1'
    type: f64
    vlen: '1'
  states: {}
- name: gnss_pvt_satellite_0
  id: gnss_pvt_satellite
  parameters:
    identifier: svid
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_signal_normalizer_0
  id: gnss_signal_normalizer
  parameters:
    itype: s16
    otype: fc32
    resolution: '12'
    vlen: '1'
  states: {}
- name: gnss_type_converter_0
  id: gnss_type_converter
  parameters:
    itype: fc64
    otype: fc32
    vlen: '1'
  states: {}
- name: gnss_type_converter_0_0_0_0
  id: gnss_type_converter
  parameters:
    itype: f64
    otype: f32
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: '1000'
    type: complex
    ymax: '200000'
    ymin: '-200000'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '25'
    srate: '50'
    type: float
    ymax: 8400+200
    ymin: 8400-200
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: fff
  states: {}

connections:
- [blocks_file_source_0, '0', gnss_signal_normalizer_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0, '0']
- [gnss_acquisition_and_tracking_0, '0', gnss_ca_symbols_to_nav_bits_0, '0']
- [gnss_acquisition_and_tracking_0, '0', gnss_type_converter_0, '0']
- [gnss_acquisition_and_tracking_0, '1', gnss_type_converter_0_0_0_0, '0']
- [gnss_ca_symbols_to_nav_bits_0, '0', gnss_nav_message_decoder_0, '0']
- [gnss_doppler_shift_0, '0', gnss_number_file_sink_0_0_2, '0']
- [gnss_nav_message_decoder_0, '0', gnss_pvt_satellite_0, '0']
- [gnss_nav_message_decoder_0, clock, gnss_pvt_satellite_0, clock]
- [gnss_nav_message_decoder_0, ephemeris, gnss_pvt_satellite_0, ephemeris]
- [gnss_pvt_satellite_0, '0', gnss_doppler_shift_0, '0']
- [gnss_pvt_satellite_0, '0', gnss_number_file_sink_0, '0']
- [gnss_pvt_satellite_0, '1', gnss_number_file_sink_0_0, '0']
- [gnss_pvt_satellite_0, '2', gnss_number_file_sink_0_0_1, '0']
- [gnss_signal_normalizer_0, '0', blocks_throttle_0, '0']
- [gnss_type_converter_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [gnss_type_converter_0_0_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', gnss_number_file_sink_0_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.5.0-1-g480f600c
